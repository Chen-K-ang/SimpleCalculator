# Keil uVision project Calculator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Calculator +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: LCD1602.c main.c key.c delay.c
